## src/modules/rover_drive_control/Kconfig
```kconfig
menuconfig MODULES_ROVER_DRIVE_CONTROL
	bool "rover_drive_control"
	default y
	---help---
		Enable support for rover_drive_control
```
